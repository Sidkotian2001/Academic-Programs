	AREA	RESET, DATA, READONLY
	EXPORT __Vectors

__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	AREA	mycode, CODE, READONLY
	ALIGN
	EXPORT Reset_Handler
	
Reset_Handler
	LDR R0, =NUM
	LDR R2, =RESULT
	LDR R1, [R0]
	AND R1, #0X0F
	CMP R1, #9
	BLS DOWN
	ADD R1, #06
DOWN	ADD R1, #0X30
	STRB R1, [R2]
	LDRB R1, [R0]
	AND R4, R1, #0XF0
	MOV R4, R4, LSR #4
	CMP R4, #9
	BLS DOWN1
	ADD R3, #6
DOWN1	ADD R4, #0X30
	STRB R4, [R2,#4]
STOP
	B STOP
	
NUM DCD 0XFF
	AREA	MYDATA, DATA, READWRITE
RESULT DCD 0
	END
	